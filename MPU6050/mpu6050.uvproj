# Keil uVision project mpu6050.uvproj, settings and files
target MPU6050 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: mpu6050
  c flags: Optim=1 OneElfS=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER, USE_STM32F4_DISCOVERY
  c include: .\src;.\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\src;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Utilities\STM32F4-Discovery;.\Delay;.\I2C;.\MPU6050
  asm define: STM32F4XX, USE_STDPERIPH_DRIVER, USE_STM32F4_DISCOVERY
  asm include: .\src;.\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\src;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Utilities\STM32F4-Discovery;.\Delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./: startup_stm32f40xx.s
    ./src/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group inc
    ./inc/: main.h stm32f4xx_conf.h stm32f4xx_it.h
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Utilities
    ./Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group Delay
    ./Delay/: delay.c
  group I2C
    ./I2C/: i2c.c
  group MPU6050
    ./MPU6050/: calibration.c calibration.h helper_3dmath.h MPU6050.c MPU6050.h MPU6050_6Axis_MotionApps20.h
